# Keil uVision project motorMode.uvproj, settings and files
target motorMode (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: motorMode +hex
  c flags: Optim=1
  c define: rvmdk PART_TM4C123GH6PM  TARGET_IS_TM4C123_RA3
  c include: ..\inc_h;C:\ti\TivaWare_C_Series-2.1.0.12573\inc;C:\ti\TivaWare_C_Series-2.1.0.12573\utils;C:\ti\TivaWare_C_Series-2.1.0.12573\grlib;C:\ti\TivaWare_C_Series-2.1.0.12573\IQmath;C:\ti\TivaWare_C_Series-2.1.0.12573\nfclib;C:\ti\TivaWare_C_Series-2.1.0.12573\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ../APP/: main.c
  group DEAL
    ../DEAL/: CAN_Deal.c Step_Deal.c Timer_Deal.c
  group DRIVE
    ../DRIVE/: GPIO_Init.c TimerInit.c Can_Init.c System_Init.c fifo.c
    ./: startup_TM4C123.s
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/rvmdk/: driverlib.lib
  group include
    ./: readme.txt
